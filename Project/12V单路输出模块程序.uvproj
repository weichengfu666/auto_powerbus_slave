# Keil uVision project 12V单路输出模块程序.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 12V单路输出模块程序 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver;.\bsp
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c COM.c Clock.c ZongZhiXin.c CRC16.c
  group driver
    ./driver/: delay.c GPIO.c timer.c WDT.c EEPROM.c PWM.C
  group bsp
    ./bsp/: bsp_config.c bsp_led.c bsp_display.c bsp_eeprom.c bsp_test.c bsp_lock.c
  group doc
    ./doc/: 未解决问题.txt 已解决问题.txt 配置.txt
